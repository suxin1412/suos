# Keil uVision project suos.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: suos +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\os;.\user
  group os
    ./: log.txt
    ./os/: OS_Core.c OS_kernel.asm indicator.c handle.c
  group user
    ./user/: main.c Snake.c Pellet.c
